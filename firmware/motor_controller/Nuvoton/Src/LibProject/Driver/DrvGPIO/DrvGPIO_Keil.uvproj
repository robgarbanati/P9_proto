# Keil uVision project DrvGPIO_Keil.uvproj, settings and files
target F064_Debug (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: DrvGPIOD_F064_Keil (library)
  AfterMake: xcopy /Y F064\Debug\DrvGPIOD_F064_Keil.lib ..\..\..\..\Lib\Driver
  c flags: Optim=1 OneElfS=1
  c define: __N572F064__
  c include: .;../../../../../HW/Include;../../../../Include
  asm define: __N572F064__
  group F064_Source Files
    ./: DrvGPIO.c
target F064_Release (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: DrvGPIO_F064_Keil (library)
  AfterMake: xcopy /Y F064\Release\DrvGPIO_F064_Keil.lib ..\..\..\..\Lib\Driver
  c flags: Optim=4 OneElfS=1
  c define: __N572F064__
  c include: .;../../../../../HW/Include;../../../../Include
  asm define: __N572F064__
target F065_Debug (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: DrvGPIOD_F065_Keil (library)
  AfterMake: xcopy /Y F065\Debug\DrvGPIOD_F065_Keil.lib ..\..\..\..\Lib\Driver
  c flags: Optim=1 OneElfS=1
  c define: __N572F065__
  c include: .;../../../../../HW/Include;../../../../Include
  asm define: __N572F065__
target F065_Release (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: DrvGPIO_F065_Keil (library)
  AfterMake: xcopy /Y F065\Release\DrvGPIO_F065_Keil.lib ..\..\..\..\Lib\Driver
  c flags: Optim=4 OneElfS=1
  c define: __N572F065__
  c include: .;../../../../../HW/Include;../../../../Include
  asm define: __N572F065__
target F072_Debug (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: DrvGPIOD_F072_Keil (library)
  AfterMake: xcopy /Y F072\Debug\DrvGPIOD_F072_Keil.lib ..\..\..\..\Lib\Driver
  c flags: Optim=1 OneElfS=1
  c define: __N572F072__
  c include: .;../../../../../HW/Include;../../../../Include
  asm define: __N572F072__
target F072_Release (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: DrvGPIO_F072_Keil (library)
  AfterMake: xcopy /Y F072\Release\DrvGPIO_F072_Keil.lib ..\..\..\..\Lib\Driver
  c flags: Optim=4 OneElfS=1
  c define: __N572F072__
  c include: .;../../../../../HW/Include;../../../../Include
  asm define: __N572F072__
target P072_Debug (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: DrvGPIOD_P072_Keil (library)
  AfterMake: xcopy /Y P072\Debug\DrvGPIOD_P072_Keil.lib ..\..\..\..\Lib\Driver
  c flags: Optim=1 OneElfS=1
  c define: __N572P072__
  c include: .;../../../../../HW/Include;../../../../Include
  asm define: __N572P072__
target P072_Release (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: DrvGPIO_P072_Keil (library)
  AfterMake: xcopy /Y P072\Release\DrvGPIO_P072_Keil.lib ..\..\..\..\Lib\Driver
  c flags: Optim=4 OneElfS=1
  c define: __N572P072__
  c include: .;../../../../../HW/Include;../../../../Include
  asm define: __N572P072__
