# Keil uVision project DrvADC_Keil.uvproj, settings and files
target F064_Debug (ARM-ADS)
  device: N572F064 Nuvoton
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0-0xFFFF) CLOCK(48000000) CPUTYPE("Cortex-M0")
  output: DrvADCD_F064_Keil (library)
  AfterMake: xcopy /Y F064\Debug\DrvADCD_F064_Keil.lib ..\..\..\..\Lib\Driver
  c flags: Optim=1 OneElfS=1
  c define: __N572F064__
  c include: .;../../../../../HW/Include;../../../../Include
  asm define: __N572F064__
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Files
    ./: DrvADC.c
target F064_Release (ARM-ADS)
  device: N572F064 Nuvoton
  cpu: as above
  output: DrvADC_F064_Keil (library)
  AfterMake: xcopy /Y F064\Release\DrvADC_F064_Keil.lib ..\..\..\..\Lib\Driver
  c flags: Optim=4 OneElfS=1
  c define: __N572F064__
  c include: .;../../../../../HW/Include;../../../../Include
  asm define: __N572F064__
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
target F065_Debug (ARM-ADS)
  device: N572F065 Nuvoton
  cpu: as above
  output: DrvADCD_F065_Keil (library)
  AfterMake: xcopy /Y F065\Debug\DrvADCD_F065_Keil.lib ..\..\..\..\Lib\Driver
  c flags: Optim=1 OneElfS=1
  c define: __N572F065__
  c include: .;../../../../../HW/Include;../../../../Include
  asm define: __N572F065__
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
target F065_Release (ARM-ADS)
  device: N572F065 Nuvoton
  cpu: as above
  output: DrvADC_F065_Keil (library)
  AfterMake: xcopy /Y F065\Release\DrvADC_F065_Keil.lib ..\..\..\..\Lib\Driver
  c flags: Optim=4 OneElfS=1
  c define: __N572F065__
  c include: .;../../../../../HW/Include;../../../../Include
  asm define: __N572F065__
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
target F072_Debug (ARM-ADS)
  device: N572F072 Nuvoton
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0-0x11FFF) CLOCK(48000000) CPUTYPE("Cortex-M0")
  output: DrvADCD_F072_Keil (library)
  AfterMake: xcopy /Y F072\Debug\DrvADCD_F072_Keil.lib ..\..\..\..\Lib\Driver
  c flags: Optim=1 OneElfS=1
  c define: __N572F072__
  c include: .;../../../../../HW/Include;../../../../Include
  asm define: __N572F072__
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
target F072_Release (ARM-ADS)
  device: N572F072 Nuvoton
  cpu: as above
  output: DrvADC_F072_Keil (library)
  AfterMake: xcopy /Y F072\Release\DrvADC_F072_Keil.lib ..\..\..\..\Lib\Driver
  c flags: Optim=4 OneElfS=1
  c define: __N572F072__
  c include: .;../../../../../HW/Include;../../../../Include
  asm define: __N572F072__
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
target P072_Debug (ARM-ADS)
  device: N572P072 Nuvoton
  cpu: as above
  output: DrvADCD_P072_Keil (library)
  AfterMake: xcopy /Y P072\Debug\DrvADCD_P072_Keil.lib ..\..\..\..\Lib\Driver
  c flags: Optim=1 OneElfS=1
  c define: __N572P072__
  c include: .;../../../../../HW/Include;../../../../Include
  asm define: __N572P072__
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
target P072_Release (ARM-ADS)
  device: N572P072 Nuvoton
  cpu: as above
  output: DrvADC_P072_Keil (library)
  AfterMake: xcopy /Y P072\Release\DrvADC_P072_Keil.lib ..\..\..\..\Lib\Driver
  c flags: Optim=4 OneElfS=1
  c define: __N572P072__
  c include: .;../../../../../HW/Include;../../../../Include
  asm define: __N572P072__
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
