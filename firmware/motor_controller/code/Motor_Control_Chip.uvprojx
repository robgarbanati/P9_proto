# Keil uVision project Motor_Control_Chip.uvprojx, settings and files
target F072_Debug (ARM-ADS)
  device: N572F072 Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.0.3
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0-0x11FFF) CLOCK(48000000) CPUTYPE("Cortex-M0")
  output: Motor_Control_Chip
  AfterMake: fromelf --i32combined --output F072\Debug\Motor_Control_Chip.hex F072\Debug\Motor_Control_Chip.axf
  AfterMake: ../Nuvoton/WindowsPlatform/Tool/Utility/hex2bin F072\Debug\Motor_Control_Chip.hex
  c flags: Optim=1
  c define: __N572F072__
  c include: .;../Nuvoton/HW/Include;../Nuvoton/Include;../RTX/INC;nRF8001;nRF8001/hal
  asm define: __N572F072__
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\Motor_Control_Chip_F072.ld
  link misc: --map --datacompressor=off --info=inline --entry Reset_Handler --remove --keep startup_N572_ISP.o(JMPTABLE) --userlibpath="../Nuvoton/Lib" Driver_F072_keil.lib
  group Header Files
    ./: Main.h Spi.h SysClkConfig.h Debug.h Adc.h PWM.h app_SinDrive.h app_drv8301.h app_SoftPWM.h app_OptoSensor.h
  group Source Files
    ../Nuvoton/HW/Include/: SFR.c
    ./: Main.c Spi.c Adc.c PWM.c app_SinDrive.c app_drv8301.c app_SoftPWM.c app_OptoSensor.c
  group CMSIS
    ../Nuvoton/CMSIS/CM0/: core_cm0.c
    ../Nuvoton/CMSIS/CM0/startup/arm/: startup_N572_ISP.s
  group Lib Files
    ../Nuvoton/Lib/Commu/: SemiHost_Keil.lib
  group Documentation
    ./: Abstract.txt
target F072_Release (ARM-ADS)
  device: N572F072 Nuvoton
  cpu: as above
  output: Motor_Control_Chip
  AfterMake: fromelf --i32combined --output F072\Release\Motor_Control_Chip.hex F072\Release\Motor_Control_Chip.axf
  AfterMake: ../../../../WindowsPlatform/Tool/Utility/hex2bin F072\Release\Motor_Control_Chip.hex
  c flags: Optim=3 OneElfS=1
  c define: __EVB_V1_0__,__N572F072__
  c include: .;../../../../HW/Include;../../../Include;../RTX/INC;nRF8001;nRF8001/hal
  asm define: __N572F072__
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\Motor_Control_Chip_F072.ld
  link misc: --map --datacompressor=off --info=inline --entry Reset_Handler --remove --userlibpath="../../../lib" Driver_F072_keil.lib
