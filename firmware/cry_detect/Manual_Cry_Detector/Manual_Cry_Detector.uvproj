# Keil uVision project Manual_Cry_Detector.uvproj, settings and files
target F072_Debug (ARM-ADS)
  device: N572F072 Nuvoton
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0-0x11FFF) CLOCK(48000000) CPUTYPE("Cortex-M0")
  output: Manual_Cry_Detector
  AfterMake: fromelf --i32combined --output F072\Debug\Manual_Cry_Detector.hex F072\Debug\Manual_Cry_Detector.axf
  AfterMake: ../Nuvoton/WindowsPlatform/Tool/Utility/hex2bin F072\Debug\Manual_Cry_Detector.hex
  c flags: Optim=1
  c define: __N572F072__
  c include: .;../Nuvoton/HW/Include;../Nuvoton/Include
  asm define: __N572F072__
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\Manual_Cry_Detector_F072.ld
  link misc: --map --datacompressor=off --info=inline --entry Reset_Handler --remove --keep startup_N572_ISP.o(JMPTABLE) --userlibpath="../Nuvoton/Lib" SDK_F072_Keil.lib Driver_F072_keil.lib
  group Header Files
    ./: SysClkConfig.h Debug.h DirDetect.h Spi.h
  group Source Files
    ../Nuvoton/HW/Include/: SFR.c
    ./: Main.c DirDetect.c Spi.c
  group CMSIS
    ../Nuvoton/CMSIS/CM0/: core_cm0.c
    ../Nuvoton/CMSIS/CM0/startup/arm/: startup_N572_ISP.s
  group Lib Files
    ../Nuvoton/Lib/Commu/: SemiHost_Keil.lib
  group Documentation
    ./: Abstract.txt
target F072_Release (ARM-ADS)
  device: N572F072 Nuvoton
  cpu: as above
  output: Manual_Cry_Detector
  AfterMake: fromelf --i32combined --output F072\Release\Manual_Cry_Detector.hex F072\Release\Manual_Cry_Detector.axf
  AfterMake: ../../../../WindowsPlatform/Tool/Utility/hex2bin F072\Release\Manual_Cry_Detector.hex
  c flags: Optim=3 OneElfS=1
  c define: __EVB_V1_0__,__N572F072__
  c include: .;../../../../HW/Include;../../../Include;../RTX/INC;nRF8001;nRF8001/hal
  asm define: __N572F072__
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\EVB_Template_F072_Keil.ld
  link misc: --map --datacompressor=off --info=inline --entry Reset_Handler --remove --userlibpath="../../../lib" Driver_F072_keil.lib
