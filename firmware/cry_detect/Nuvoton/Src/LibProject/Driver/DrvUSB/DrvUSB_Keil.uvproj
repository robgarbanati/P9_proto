# Keil uVision project DrvUSB_Keil.uvproj, settings and files
target F065_Debug (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: DrvUSBD_F065_Keil (library)
  AfterMake: xcopy /Y F065\Debug\DrvUSBD_F065_Keil.lib ..\..\..\..\Lib\Driver
  c flags: Optim=1 OneElfS=1
  c define: __N572F065__
  c misc: --diag_remark=66
  c include: .;../../../../../HW/Include;../../../../Include
  asm define: __N572F065__
  group Source Files
    ./: DrvUSB.c CtrlFramework.c DevFramework.c
target F065_Release (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: DrvUSB_F065_Keil (library)
  AfterMake: xcopy /Y F065\Release\DrvUSB_F065_Keil.lib ..\..\..\..\Lib\Driver
  c flags: Optim=4 OneElfS=1
  c define: __N572F065__
  c misc: --diag-remark=66
  c include: .;../../../../../HW/Include;../../../../Include
  asm define: __N572F065__
