# Keil uVision project DrvSYS_Keil.uvproj, settings and files
target F064_Debug (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: DrvSYSD_F064_Keil (library)
  AfterMake: xcopy /Y F064\Debug\DrvSYSD_F064_Keil.lib ..\..\..\..\Lib\Driver
  c flags: Optim=1 OneElfS=1
  c define: __N572F064__
  c include: .;../../../../../HW/Include;../../../../Include
  asm define: __N572F064__
  group Source Files
    ./: DrvSYS.c
target F064_Release (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: DrvSYS_F064_Keil (library)
  AfterMake: xcopy /Y F064\Release\DrvSYS_F064_Keil.lib ..\..\..\..\Lib\Driver
  c flags: Optim=4 OneElfS=1
  c define: __N572F064__
  c include: .;../../../../../HW/Include;../../../../Include
  asm define: __N572F064__
target F065_Debug (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: DrvSYSD_F065_Keil (library)
  AfterMake: xcopy /Y F065\Debug\DrvSYSD_F065_Keil.lib ..\..\..\..\Lib\Driver
  c flags: Optim=1 OneElfS=1
  c define: __N572F065__
  c include: .;../../../../../HW/Include;../../../../Include
  asm define: __N572F065__
target F065_Release (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: DrvSYS_F065_Keil (library)
  AfterMake: xcopy /Y F065\Release\DrvSYS_F065_Keil.lib ..\..\..\..\Lib\Driver
  c flags: Optim=4 OneElfS=1
  c define: __N572F065__
  c include: .;../../../../../HW/Include;../../../../Include
  asm define: __N572F065__
target F072_Debug (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: DrvSYSD_F072_Keil (library)
  AfterMake: xcopy /Y F072\Debug\DrvSYSD_F072_Keil.lib ..\..\..\..\Lib\Driver
  c flags: Optim=1 OneElfS=1
  c define: __N572F072__
  c include: .;../../../../../HW/Include;../../../../Include
  asm define: __N572F072__
target F072_Release (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: DrvSYS_F072_Keil (library)
  AfterMake: xcopy /Y F072\Release\DrvSYS_F072_Keil.lib ..\..\..\..\Lib\Driver
  c flags: Optim=4 OneElfS=1
  c define: __N572F072__
  c include: .;../../../../../HW/Include;../../../../Include
  asm define: __N572F072__
target P072_Debug (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: DrvSYSD_P072_Keil (library)
  AfterMake: xcopy /Y P072\Debug\DrvSYSD_P072_Keil.lib ..\..\..\..\Lib\Driver
  c flags: Optim=1 OneElfS=1
  c define: __N572P072__
  c include: .;../../../../../HW/Include;../../../../Include
  asm define: __N572P072__
target P072_Release (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: DrvSYS_P072_Keil (library)
  AfterMake: xcopy /Y P072\Release\DrvSYS_P072_Keil.lib ..\..\..\..\Lib\Driver
  c flags: Optim=4 OneElfS=1
  c define: __N572P072__
  c include: .;../../../../../HW/Include;../../../../Include
  asm define: __N572P072__
